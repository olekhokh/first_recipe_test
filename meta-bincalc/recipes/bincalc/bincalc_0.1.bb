SUMMARY = "bitbake-layers recipe"
DESCRIPTION = "Recipe created by bitbake-layers"
PRIORITY = "optional"
SECTION = "example"
LICENSE = 'CLOSED'

SRC_URI="git://github.com/Vladislavo/binaryCalculator.git"
S = "${WORDDIR}/git"

